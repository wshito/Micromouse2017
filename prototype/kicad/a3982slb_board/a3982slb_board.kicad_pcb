# Repository wshito/Micromouse2017

## KiCad design prototype/kicad/a3982slb_board/a3982slb_board.kicad_pcb

File prototype/kicad/a3982slb_board/README.md:

# The evaluation board for the stepping motor driver a3982slb

## The Characteristics of a3982slb stepping motor driver

- The bipolar stepper motors in full- and half-step modes.
- No power-on or off sequencing is required.
- Automatically chooses the decay mode from SLOW DECAY and MIXED DECAY.
- Internal UVLO and thermal shutdown circuitry.
- The output drive capacity of up to 35V and ±2A.
- The logic voltage accepts between 3.0V and 5.5V.

## Files

- `a3982slb_board.pro`: The main project file for KiCAD.
- `a3982slb_board.sch`: KiCAD schematic file.
- `a3982slb_board.kicad_pcb`: KiCAD pcb file.
- `a3982slb_board-cache.lib`: KiCAD cache for parts library.
- `output`: Contains biproducts from the KiCAD project.
   - `a3982slb_board.csv`: Bill of Devices which includes the URLs of shops.
   - `a3982slb_board_Gerber.zip`: Gerber files for [Elecrow](https:www.elecrow.com) or [PCBGOGO](https://www.pcbgogo.com).
   - `board_layout.pdf`

## About the Bill of Devices

In the schematic, R1 which determines the fixed off-time is set 25kΩ.
However, the BOD lists the URL for 30kΩ because I could not find the one with 25kΩ.  This makes the fixed off-time approximately 6.060606us longer and becomes about 36.363636us. 

## Japanese translation

### a3982slb ステッピングモーター・ドライバの特徴

- バイポーラ駆動方式のステッピングモーター・ドライバ．
- ロジック側電源とモーター側電源の ON・OFF シーケンスに制約がない．どちらから先に電源を入れても，また，OFFにしても問題ない．
- ステップ信号を入力するだけで，チョッピング制御の電流減衰モードが SLOW DECAY と MIXED DECAY から自動選択される．
- 電源電圧低下検出保護機能（UVLO）と熱保護機能（TSD）を搭載．
- 出力は 35V，±2.0A まで対応．
- ロジック電源は 3.0 〜 5.5V 対応．

## Files

- `a3982slb_board.pro`: KiCAD用プロジェクトファイル．
- `a3982slb_board.sch`: KiCAD用回路図ファイル．
- `a3982slb_board.kicad_pcb`: KiCAD用基盤レイアウトファイル．
- `a3982slb_board-cache.lib`: KiCAD cache for parts library.
- `output`: KiCADプロジェクトから生成したファイルを格納．
   - `a3982slb_board.csv`: パーツの入手先URLを記したBOD．
   - `a3982slb_board_Gerber.zip`: [Elecrow](https://www.elecrow.com) か [PCBGOGO](https://www.pcbgogo.jp) 用のガーバーファイルのアーカイブ.
   - `board_layout.pdf`: 基盤レイアウト．

### BOD について

回路図では，固定OFF時間を決める R1 は 25kΩ になっているが，部品が見つけられなかったので，BOD では 30kΩ の入手先を記載している．これにより，固定時間が約 6.060606μ 秒長くなり 36.363636μ 秒になる．ちなみに 25kΩなら約 30.30303μ 秒である．

### 使い方

- Logic 電源を 3.3V に設定し，可変抵抗は 0Ω 側最小値にセット．
- 負荷側電源を 9V 〜 11.1V に設定．
- Vbb_Load 側にあるGND は Logic 電源用の GND．Vbb_Logic 側にある GND がモーター電源用 GND．サイドが逆になるので注意．両者は基盤上で1点アースを取っている．

Parts:
C1, C3: 0.1u; C_0603_HandSoldering; Voltage 50V
C2: 0.22u; C_0603_HandSoldering; Voltage 25V
C4: 100u; UCB1H101MNL1GS_HandSoldering; Voltage 50V
C5: 0.22u; C_0603_HandSoldering; Voltage 50V
C6: 10u; C_0603_HandSoldering; Voltage 10V
C7: 0.22u; C_0603_HandSoldering; Voltage 10V
P1: CONN_01X07; Pin_Header_Straight_1x07
P2: CONN_01X06; Pin_Header_Straight_1x06
R1, R2: 0.33; R_2512_HandSoldering
R3: 25K; R_0603_HandSoldering
R4: 2.4K; R_0603_HandSoldering
RV1: 10K; G43A
U1: A3982; SOIC-24W_7.5x15.4mm_Pitch1.27mm
W1: TEST_1P; Measurement_Point_Square-TH_Small

Connections:
DIR: P1.5, U1.20 (DIR)
ENABLE: P2.5, U1.5 (ENABLE)
GND: C2.2, C4.2, C5.1, C6.2, C7.1, P1.4, P2.4, R1.2, R2.1, R3.2, R4.2, U1.6 (PGND), U1.7 (PGND), U1.18 (PGND), U1.19 (PGND)
MS1: P2.6, U1.12 (MS1)
unnamed: C1.1, U1.10 (VCP)
unnamed: C2.1, U1.11 (VREG)
unnamed: C3.1, U1.8 (CP1)
unnamed: C3.2, U1.9 (CP2)
unnamed: R1.1, U1.2 (SENSE2)
unnamed: R2.2, U1.23 (SENSE1)
unnamed: R3.1, U1.14 (ROSC)
unnamed: R4.1, RV1.3
unnamed 12: RV1.2, U1.17 (REF), W1.1; also elsewhere on the board
OUT1A: P1.7, U1.24 (OUT1A)
OUT1B: P1.6, U1.21 (OUT1B)
OUT2A: P2.2, U1.1 (OUT2A)
OUT2B: P2.3, U1.4 (OUT2B)
RESET: P1.2, U1.13 (RESET)
STEP: P1.3, U1.16 (STEP)
VBB_LOAD: C1.2, C4.1, C5.2, P2.1, U1.3 (VBB2), U1.22 (VBB1_LOAD)
VDD_LOGIC: C6.1, C7.2, P1.1, RV1.1, U1.15 (VDD_LOGIC)

Notes on the sheet:
Vdd = 3V to 5.5V. Make sure to set the R? big enough to make Vref less than 4V when you use Vdd > 4, since Vref Max is 4V. Use TP1 to check the Vref voltage. Vddに4V以上印可する場合はVrefに4V以上印可しないように 可変抵抗を調節すること．
Vbb Max 35V Output max 2A
Swapped the pin in schematic. The top pin is the pin 1.

Board: 2 copper layers, 21.3 x 40.9 mm, 16 parts (0 on the bottom side), 21 nets.

Other parts of the board:
Test: TEST_1P; PINTST

Their connections:
unnamed 12: Test.1; also elsewhere on the board

## Commit log

2017-04-29 first import
2017-05-04 Created 17PM-K044 stepping motor 3D model.
2017-05-04 Added motor mount 3d cad project.
2017-05-04 Added gitignore
2017-05-04 added kicad ignore files.
2017-05-04 Added kicad micromouse2017 project.
2017-05-05 fusion succeeded
2017-05-05 final version for the motor.
2017-05-05 basic shape is made.
2017-05-06 chassis' first draft.
2017-05-06 Chassis is completed.
2017-05-06 Wire terminal is moved to the other side for assembly workbench.
2017-05-06 Rotated motors are added for assembly purpose.
2017-05-06 The width is adjusted.
2017-05-06 The motors are installed.
2017-05-06 Wheel is completed.
2017-05-06 The motor axis is adjusted.
2017-05-06 Assembled motors and wheels.
2017-05-06 Completed the motor mount design. But it will not be used.
2017-05-06 Removed the references to right and left motor and wheel.
2017-05-07 Added the wire on the motor.
2017-05-07 created M3 20mm spacer.
2017-05-07 Added the spacers for the bottom pcb.
2017-05-16 Added A3982 motor driver evaulation board project.
2017-05-16 Cleaned up rescue.lib and some garbage files.
2017-05-22 Routing completed.
2017-05-22 Moved logic GND.
2017-05-23 Silk is completed. All done.
2017-05-23 Moved into a3982slb_board folder.
2017-05-23 Added *.kicad_pcb-bak to ignore.
2017-05-24 Started stm32f401rct6 board project.
2017-06-01 USART, boot switches, power supplies are implemented.
2017-07-03 Added BOM information on schematic.
2018-02-28 added readme and biproduct files.
2018-02-28 fixed markdown
2018-02-28 added Japanes explanations for files.
2018-02-28 fixed URL
2018-02-28 added some parts
2018-02-28 Reorganized dir layout
2018-02-28 initial skelton project
2018-02-28 changed the project name
2018-02-28 changed the project root's dir name
2018-02-28 deleted emacs backup file
2018-03-01 added clock settings
2018-03-01 minor fix
2018-03-02 added WIP
